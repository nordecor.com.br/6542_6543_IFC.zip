Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-12-05T16:46:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 05 16:46:39 2024 * Host: MichellyManno * Database: C:\Users\MICHEL~1\AppData\Local\Temp\7f062ced-7776-4c92-b9cd-e447f267636d\32c7ebf3-bc81-4739-bdaa-f8ccd8225b6c\ifc * Database version: 5507 * Database creation date: Thu Dec 05 16:46:38 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 05 16:46:39 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 05 16:46:39 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6542, Mini_Spot_Ollo_6542_6543_Nordecor_IFC:6542:329949
In: Nível 1
Type - Material: Metal - Alumínio - Branco, Acrílico colméia, LED, Plástico Preto
Type - Cotas - Inclinação: 0 deg; Inclinação do foco: 0 deg; Rotação: 0 deg
Type - Dados - Data da atualização: 02/12/2024; Versão: 1
Type - Dados de identidade - Aplicação: Forro; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Luminária de embutir com borda, acabamento branco, LED 3W 3000K 15º; Desenvolvedor: Check BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 anos; Grau de proteção: IP20; Localização: Camboriú/SC - Brasil; Modelo: 6542; Nome do tipo: 6542; Número OmniClass: 23.80.70.11.14.11; Tipo de imagem: Imagem raster: 6542.png; Título OmniClass: Downlights; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/mini-spot-led-de-embutir-ollo-3w-3-000k/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso: 0.055
Type - Fotométricos - Fluxo luminoso: 180 lm; Grau de abertura: 15 deg; IRC (RA): >90; Potência: 3 W; Temperatura de cor: 3000 K
Type - Gráficos - Simbologia: Imagem raster: 6542 2D.png
Type - Materiais e acabamentos - Luminária: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Mini_Spot_Ollo_6542_6543_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Cotas - Área: 0.0139966 m2; Volume: 0.0000337143 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Mini_Spot_Ollo_6542_6543_Nordecor_IFC: 6542; Família e tipo: Mini_Spot_Ollo_6542_6543_Nordecor_IFC: 6542; ID de tipo: Mini_Spot_Ollo_6542_6543_Nordecor_IFC: 6542; Tipo: Mini_Spot_Ollo_6542_6543_Nordecor_IFC: 6542
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
